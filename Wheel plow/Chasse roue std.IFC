Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Chasse roue std.IFC
Time: 2020-07-03T10:59:54
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: Platine chasse-roue_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: Platine chasse-roue_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 8.60896; Area Measure: 0.576388; Volume Measure: 0.00111805

# IfcBuildingElementProxy: SPE-ACCE-CHA-1400-004_Default
In: Default Storey
Material: S 235
